# Keil uVision project Project_Yfc.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_Yfc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\Libraries\CMSIS\startup;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Public;..\Hardware;..\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_usart.c
  group FatFs
    ../FatFs/: ff.c ff.h ffunicode.c diskio.c diskio.h ffconf.h
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Indicator_LED.c Indicator_LED.h
  group Hardware
    ../Hardware/: tft_display.c tft_display.h esp8266_com.c esp8266_com.h bsp_w25qx.c bsp_w25qx.h bsp_rtc.c bsp_rtc.h bsp_date.c bsp_date.h bsp_calendar.c bsp_calendar.h bsp_key.c bsp_key.h
  group Public
    ../Public/: bsp_usart.c bsp_usart.h bsp_systick.c bsp_systick.h Delay.c Delay.h
  group DOC
    ../Doc/: Readme.txt
