# Keil uVision project Project_NWS_yfc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project_NWS_yfc
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\System;.\Public;.\Hardware
  group System
    ./System/: System_Init.c System_Init.h UART.c UART.h
  group User
    ./User/: main.c STARTUP.A51 Interrupt.c
  group Public
    ./Public/: Delay.c Delay.h
